options:
  parameters:
    author: Lab
    generate_options: qt_gui
    id: AIS_channel_simulator
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bit_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: ../input_data.bin
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ..\output_data.bin
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '0.9'
    type: complex
  states: {}
- name: blocks_multiply_const_xx_0_0
  id: blocks_multiply_const_xx
  parameters:
    const: 1/0.9
    type: complex
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.0'
    seed: '0'
    taps: '1.0'
  states: {state: disabled}
- name: channels_channel_model_1
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.0'
    seed: '0'
    taps: '1.0'
  states: {}
- name: digital_gmsk_demod_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: int(samp_rate/bit_rate)
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.4'
    samples_per_symbol: int(samp_rate/bit_rate)
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: Tx
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: Rx
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Tx
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: Rx
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_const_xx_0, '0', virtual_sink_0, '0']
- [blocks_multiply_const_xx_0_0, '0', digital_gmsk_demod_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_throttle2_0, '0', digital_gmsk_mod_0, '0']
- [channels_channel_model_0, '0', virtual_sink_1, '0']
- [channels_channel_model_1, '0', virtual_sink_1, '0']
- [digital_gmsk_demod_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_gmsk_mod_0, '0', blocks_multiply_const_xx_0, '0']
- [virtual_source_0, '0', channels_channel_model_0, '0']
- [virtual_source_0, '0', channels_channel_model_1, '0']
- [virtual_source_1, '0', blocks_multiply_const_xx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
