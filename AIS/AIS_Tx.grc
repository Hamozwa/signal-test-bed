options:
  parameters:
    generate_options: qt_gui
    id: AIS_Tx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bit_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ..\output_data.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '0.9'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: digital_gmsk_demod_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
  states: {state: disabled}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.4'
    samples_per_symbol: int(samp_rate/bit_rate)
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    freq0: 161975e3
    gain0: '10'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_sink_0_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    freq0: 161975e3
    gain0: '10'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}

connections:
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_const_xx_0, '0', osmosdr_sink_0, '0']
- [blocks_multiply_const_xx_0, '0', osmosdr_sink_0_0, '0']
- [blocks_multiply_const_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle2_0, '0', digital_gmsk_mod_0, '0']
- [digital_gmsk_mod_0, '0', blocks_multiply_const_xx_0, '0']
- [digital_gmsk_mod_0, '0', digital_gmsk_demod_0, '0']
- [digital_gmsk_mod_0, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
